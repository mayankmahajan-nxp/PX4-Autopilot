## src/modules/gps_uart_sender/Kconfig
```kconfig
menuconfig MODULES_GPS_UART_SENDER
	bool "gps_uart_sender"
	default y
	---help---
		Enable support for gps_uart_sender
```
